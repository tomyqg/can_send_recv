# IAR project tag.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xE; PF_CORE_STM32F103; USE_HAL_DRIVER; USE_BAND_470; LORA_RADIO_SX127X
  ICCARM.CCIncludePath2: ..\..\..\; ..\..\..\wsnos\; ..\..\..\apps\; ..\..\..\app\tag\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: wireless.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app/tag
    ../../../app/tag/: app.c app.h app_product_test.c app_product_test.h node_cfg.h wsnos_config.h
  group app/tag/app_modules
    ../../../app/tag/app_modules/: app_module_alg.c app_module_alg.h app_module_alg_handler.c app_module_alg_handler.h app_module_cfg.c app_module_cfg.h app_module_frame.c app_module_frame.h app_module_send.c app_module_send.h
  group wsnos
    ../../../wsnos/: gz_sdk.h
  group wsnos/common/dev
    ../../../wsnos/common/dev/: dev.h radio_defs.h
  group wsnos/common/dev/adxl345
    ../../../wsnos/common/dev/adxl345/: adxl345.c adxl345.h
  group wsnos/common/dev/mamx845x
    ../../../wsnos/common/dev/mamx845x/: mamx845x.c mamx845x.h
  group wsnos/common/hal
    ../../../wsnos/common/hal/: hal.h hal_board.c hal_board.h hal_clock.c hal_clock.h hal_energy.c hal_energy.h hal_gpio.c hal_gpio.h hal_low_power.h hal_nvmem.c hal_nvmem.h hal_timer.c hal_timer.h hal_uart.c hal_uart.h
  group wsnos/common/lib
    ../../../wsnos/common/lib/: aes.c aes.h clist.c clist.h cmac.c cmac.h crc.c crc.h data_type_def.h debug.c debug.h id_rules.c id_rules.h lib.h list.c list.h mpool.c mpool.h portablelonglong.c portablelonglong.h printf.c printf.h serial.c serial.h sqqueue.c sqqueue.h srandom.c srandom.h utilities.h
  group wsnos/common/unity
    ../../../wsnos/common/unity/: unity.c unity.h unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h unity_internals.h
  group wsnos/platform
    ../../../wsnos/platform/: platform.h platform_def.h
  group wsnos/platform/stm32f103/drivers
    ../../../wsnos/platform/stm32f103/drivers/: adxl345_arch.c adxl345_arch.h board.c board.h can.c can.h clock.c clock.h driver.h flash.c flash.h gpio.c gpio.h mamx845x_arch.c mamx845x_arch.h rtimer_arch.c rtimer_arch.h spi.c spi.h stm32f1xx_it.c stm32f1xx_it.h sx1276_arch.c sx1276_arch.h uart.c uart.h uart_4.c uart_4.h wdt.c wdt.h
  group wsnos/platform/stm32f103/init
    ../../../wsnos/platform/stm32f103/init/: main.c startup_stm32f103xe.s
  group wsnos/platform/stm32f103/libs/cmsis
    ../../../wsnos/platform/stm32f103/libs/cmsis/: stm32f103xe.h stm32f1xx.h stm32f1xx_hal_conf.h system_stm32f1xx.c system_stm32f1xx.h
  group wsnos/platform/stm32f103/libs/STM32F1xx_HAL_Driver/Inc
    ../../../wsnos/platform/stm32f103/libs/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.h stm32f1xx_hal_can_ex.h stm32f1xx_hal_cec.h stm32f1xx_hal_conf_template.h stm32f1xx_hal_cortex.h stm32f1xx_hal_crc.h stm32f1xx_hal_dac.h stm32f1xx_hal_dac_ex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_eth.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_hcd.h stm32f1xx_hal_i2c.h stm32f1xx_hal_i2s.h stm32f1xx_hal_irda.h stm32f1xx_hal_iwdg.h stm32f1xx_hal_nand.h stm32f1xx_hal_nor.h stm32f1xx_hal_pccard.h stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.h stm32f1xx_hal_sd.h stm32f1xx_hal_smartcard.h stm32f1xx_hal_spi.h stm32f1xx_hal_sram.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h stm32f1xx_hal_wwdg.h stm32f1xx_ll_fsmc.h stm32f1xx_ll_sdmmc.h stm32f1xx_ll_usb.h
  group wsnos/platform/stm32f103/libs/STM32F1xx_HAL_Driver/Inc/Legacy
    ../../../wsnos/platform/stm32f103/libs/STM32F1xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group wsnos/platform/stm32f103/libs/STM32F1xx_HAL_Driver/Src
    ../../../wsnos/platform/stm32f103/libs/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group wsnos/stack
    ../../../wsnos/stack/: stack.h
  group wsnos/stack/SSN
    ../../../wsnos/stack/SSN/: stack.c
  group wsnos/stack/SSN/common
    ../../../wsnos/stack/SSN/common/: pbuf.c pbuf.h prim.h sbuf.c sbuf.h
  group wsnos/stack/SSN/custom/mac
    ../../../wsnos/stack/SSN/custom/mac/: mac.c mac.h mac_ap_handle.c mac_assoc.c mac_assoc.h mac_assoc_table.c mac_assoc_table.h mac_config.c mac_config.h mac_ctrl.c mac_ctrl.h mac_ed_handle.c mac_handle.h mac_interface.h mac_neighbor.c mac_neighbor.h mac_packet.c mac_packet.h mac_queue.c mac_queue.h mac_rp_handle.c
  group wsnos/stack/SSN/custom/nwk
    ../../../wsnos/stack/SSN/custom/nwk/: nwk_addr.c nwk_addr.h nwk_ap_handles.c nwk_ed_handles.c nwk_frames.c nwk_frames.h nwk_handles.h nwk_interface.h nwk_route.c nwk_route.h
  group wsnos/stack/SSN/custom/phy
    ../../../wsnos/stack/SSN/custom/phy/: phy_cca.c phy_cca.h phy_packet.c phy_packet.h phy_state.c phy_state.h
  group wsnos/stack/SSN/module/mac_module
    ../../../wsnos/stack/SSN/module/mac_module/: m_lsync.c m_slot.c m_slot.h m_sync.c m_sync.h m_tran.c m_tran.h mac_module.h
  group wsnos/sys_arch
    ../../../wsnos/sys_arch/: osel_arch.c osel_arch.h
  group wsnos/sys_arch/ports/stm32f1
    ../../../wsnos/sys_arch/ports/stm32f1/: cpu_port.c wsnos_port.h wsnos_port.s
  group wsnos/sys_arch/ports/stm32l
    ../../../wsnos/sys_arch/ports/stm32l/: cpu_port.c wsnos_port.h wsnos_port.s
  group wsnos/sys_arch/wsnos
    ../../../wsnos/sys_arch/wsnos/: wsnos.h wsnos_default.h wsnos_device.c wsnos_device.h wsnos_equeue.c wsnos_equeue.h wsnos_etimer.c wsnos_etimer.h wsnos_init.c wsnos_mem.c wsnos_mem.h wsnos_pthread.c wsnos_pthread.h wsnos_sched.c wsnos_sched.h wsnos_task.c wsnos_task.h
