# IAR project detector.ewp, settings and files
configuration core430 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430F5359 MSP430F5359
  General.GStackSize2: 1024
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: SILABS_RADIO_SI446X
  ICC430.newCCIncludePaths: ..\..\..\apps\detector\node_cfg; ..\..\..\apps\; ..\..\..\common\dev\; ..\..\..\common\dev\si4463\; ..\..\..\include\; ..\..\..\include\common\lib\; ..\..\..\include\common\hal\; ..\..\..\include\common\dev\; ..\..\..\include\platform\; ..\..\..\include\sys_arch\; ..\..\..\include\stack\; ..\..\..\include\stack\common\; ..\..\..\include\stack\stack_module\; ..\..\..\include\stack\stack_module\mac_module\; ..\..\..\platform\core430\include\; ..\..\..\platform\core430\include\driver\; ..\..\..\platform\core430\osel\wsnos\detector\; ..\..\..\sys_arch\wsnos\; ..\..\..\stack\custom\nwk\; ..\..\..\stack\custom\phy\; ..\..\..\stack\custom\mac\; ..\..\..\stack\custom\mac\general\; ..\..\..\stack\custom\mac\core\sync\; ..\..\..\stack\custom\mac\core\asyn\
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: USE_LARGE_CODE_MODEL=1
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F5359.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ./: lnk430f5438.xcl
  group apps
    ../../../apps/: demo.h demo1.c demo2.c demo3.c demo4.c demo5.c node_cfg.h wsnos_config.h
  group common/hal
    ../../../common/hal/: hal_board.c hal_clock.c hal_energy.c hal_gpio.c hal_nvmem.c hal_uart.c
  group common/lib
    ../../../common/lib/: bootloader.c crc.c debug.c list.c portablelonglong.c printf.c serial.c sqqueue.c srandom.c
  group include/common/hal
    ../../../include/common/hal/: hal.h hal_board.h hal_clock.h hal_energy.h hal_gpio.h hal_low_power.h hal_nvmem.h hal_sensor.h hal_timer.h hal_uart.h
  group include/common/lib
    ../../../include/common/lib/: bootloader.h crc.h data_type_def.h debug.h lib.h list.h portablelonglong.h printf.h serial.h sqqueue.h srandom.h
  group include/platform
    ../../../include/platform/: platform.h
  group include/sys_arch
    ../../../include/sys_arch/: osel_arch.h
  group paltform/core430/driver
    ../../../platform/core430/driver/: board.c clock.c energy.c flash.c gpio.c pmap.c timer.c uart.c
  group paltform/core430/include/driver
    ../../../platform/core430/include/driver/: board.h clock.h driver.h energy.h flash.h gpio.h pmap.h rtc.h sensor.h si4463_arch.h socket.h timer.h uart.h
  group paltform/core430/main
    ../../../platform/core430/init/: cstartup.s43 main.c
  group paltform/core430/os/ports
    ../../../platform/core430/osel/wsnos/detector/: wsnos_config.h wsnos_port.c wsnos_port.h
  group sys_arch
    ../../../sys_arch/: osel_arch.c
  group sys_arch/wsnos
    ../../../sys_arch/wsnos/: wsnos_equeue.c wsnos_etimer.c wsnos_init.c wsnos_mem.c wsnos_pthread.c wsnos_sched.c wsnos_task.c
  group sys_arch/wsnos/inc
    ../../../sys_arch/wsnos/: wsnos.h wsnos_default.h wsnos_equeue.h wsnos_etimer.h wsnos_mem.h wsnos_pthread.h wsnos_sched.h wsnos_task.h
